## sdkconfig.defaults
```kconfig
# WiFi配置
CONFIG_ESP_WIFI_ENABLED=y
CONFIG_ESP_WIFI_SOFTAP_SUPPORT=y
CONFIG_ESP_WIFI_STATION_SUPPORT=y

# SmartConfig配置
CONFIG_ESP_SMARTCONFIG_ENABLE=y
```
